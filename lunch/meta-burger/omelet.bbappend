
do_get() {
        echo ${PN}: less pepper > omelet.txt
        echo ${PN}: egg >> omelet.txt
}
